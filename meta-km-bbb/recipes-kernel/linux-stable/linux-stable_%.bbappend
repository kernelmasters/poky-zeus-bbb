FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-gpio-keys-and-basic-mux-configaration.patch"
