FILESEXTRAPATHS_prepend := "${THISDIR}/patches:"
SRC_URI += "file://0005-Enter-Switch-GPIO11-Raising-Edge-Interrupt-porting-o.patch"

