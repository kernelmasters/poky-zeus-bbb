FILESEXTRAPATHS_prepend := "${THISDIR}/patches:"

SRC_URI += "file://0001-volume-up-down-switches-ADDED.patch"
